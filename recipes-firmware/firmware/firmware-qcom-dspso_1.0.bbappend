SRC_URI ="https://github.com/shudan-liu/dspo/archive/refs/heads/master.zip;name=${PBT_ARCH}"
SRC_URI[qcm6490.sha256sum] = "56d719772c60ceb237b0d46cf2cb1fafd35c2fd25a8f816e4426665876ad5934"

DSPSO:qcm6490 = "master"
