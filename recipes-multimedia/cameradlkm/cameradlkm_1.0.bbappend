SRC_URI:remove   =  "git://git.codelinaro.org/clo/le/platform/vendor/opensource/camera-kernel.git;protocol=https;rev=aefae9a7897a2ca713b60472920a6c647a8962be;branch=camera-kernel.qclinux.1.0.r1-rel;destsuffix=vendor/qcom/opensource/camera-kernel"
SRC_URI   +=  "git://github.com/shudan-liu/camera-kernel.git;protocol=https;rev=aefae9a7897a2ca713b60472920a6c647a8962be;branch=camera-kernel.qclinux.1.0.r1-rel;destsuffix=vendor/qcom/opensource/camera-kernel"
